# IAR project FlyCtrlPcbV5.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ; FWLIB\inc; CMSIS\Startup; CMSIS\System; User\inc; APP\inc; MyFwLib\inc; nmealib\include\nmea; nmealib\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlyCtrlPcbV4.srec
  ILINK.IlinkOutputFile: STM32F103-IAR.out
  ILINK.IlinkIcfFile: Config\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ; FWLIB\inc; CMSIS\Startup; CMSIS\System; User\inc; APP\inc; nmealib\include\nmea; MyFwLib\inc
  ILINK.IlinkOutputFile: FlyCtrlPcbV4.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103x8.icf
  group APP
    APP/src/: Calculation.c Canlibration.c filter.c Interact.c ISR.c main.c sys_init.c Task.c
  group CMSIS/System
    CMSIS/System/: system_stm32f10x.c
  group FWLIB
    FWLIB/src/: delay.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group MyFwLib
    MyFwLib/src/: MyIIC.c stm32f10x_MY_spi.c stm32f10x_MyFlash.c usart.c
  group NMEA
    nmealib/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
  group Startup
    CMSIS/Startup/: startup_stm32f10x_cl.s
  group User
    User/src/: BMP180.c GPS.c L3GD20.c LSM303.c Mpu6050.c ms5611.c MyNRF24L0.c QMC5883.c
    APP/src/: DataStructure.c
    APP/inc/: define.h
